# Keil uVision project Blinky.uvprojx, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Flash OPT
    ./: STM32F40xxx_41xxx_OPT.s
  group Source Files
    ./: main.c fputc_def.c
  group StdPeriphLibrary
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_gpio.c misc.c stm32f4xx_tim.c stm32f4xx_exti.c
  group STM32F4_Discovery
    ./STM32F4Discovery_BSP/: Keyboard.c LED.c GPIO_STM32F4xx.c Board_Buttons.c Board_LED.c
  group STM32F4_Startup
    ./STM32F4_Startup/: system_stm32f4xx.c startup_stm32f407xx.s stm32f4xx_conf.h stm32f4xx.h system_stm32f4xx.h
  group microphone
    ./microphone/: microphone.c sound_loudness.c microphone_functions.c libPDMFilter_Keil.lib
  group PWM
    ./PWM/: led_pwm.c led_timer.c led_pwm.h led_timer.h
  group speaker
    ./speaker/: codec.c speaker.c codec.h speaker.h
  group serial_port_usb
    ./serial_port_usb/: serial_port_usb.c
    ./serial_port_usb/usb_cdc_device/: tm_stm32f4_usb_vcp.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
target STM32F407 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: as above
  output: Blinky
  c flags: Optim=3 uC99=1
  c define: HSE_VALUE=8000000, __FPU_PRESENT=1, STM32F40_41xxx, USE_STM32F4_DISCO, STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4_Startup;.\STM32F4Discovery_BSP;.\RTOS\Inc;.\microphone;.\PWM;.\speaker
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
